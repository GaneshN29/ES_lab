	AREA RESET,DATA,READONLY
		EXPORT __Vectors
__Vectors
	DCD 0X10001000
	DCD Reset_Handler
	ALIGN
	AREA MYCODE,CODE,READONLY
	ENTRY
	EXPORT Reset_Handler
Reset_Handler
	LDR R0, =SRC1
	LDR R0, [R0]
	LDR R1, =SRC2
	LDR R1, [R1]
UP2 CMP R0, R1
	BCC STO
	SUB R0, R1
	ADD R2, #1
	B UP2
STO LDR R3, =LCM
	STR R2, [R3]
STOP 
	B STOP
SRC1 DCD 0X2E
SRC2 DCD 0X0F
	AREA MYDATA, DATA, READWRITE
LCM DCD 0
	END